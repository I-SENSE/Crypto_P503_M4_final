# Keil uVision project crupto_new_c.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: crupto_new_c
  c flags: Optim=1 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c config.h fp_generic.c P503_internal.h P503.c P503_api.h fpx.c fpx.h ec_isogeny.c sidh.c sike.c random.c random.h fips202.h fips202.c test_mul.s mul.s
  group ::Device
    RTE/Device/TM4C129ENCPDT/: startup_TM4C129.s system_TM4C129.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
